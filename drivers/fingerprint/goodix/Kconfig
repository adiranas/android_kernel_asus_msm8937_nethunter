## drivers/fingerprint/goodix/Kconfig
```kconfig
config FINGER_PRINT
	tristate "fingerprint drvier support"
	help
	  Say Y here to enable fingerprint driver support!  
```
